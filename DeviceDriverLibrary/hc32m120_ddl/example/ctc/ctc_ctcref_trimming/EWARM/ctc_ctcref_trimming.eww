<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ctc_ctcref_trimming.ewp</path>
  </project>
  <batchBuild/>
</workspace>


