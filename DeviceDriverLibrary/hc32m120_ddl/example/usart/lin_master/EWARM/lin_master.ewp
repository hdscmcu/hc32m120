# IAR project lin_master.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32M120; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\midware\lin\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lin_master.srec
  ILINK.IlinkOutputFile: lin_master.out
  ILINK.IlinkIcfFile: hc32m120.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32M120; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\midware\lin\inc; ..\..\..\..\utility
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  group (top)
    ../: Readme.txt
  group common
    ../../../../mcu/common/: system_hc32m120.c
    ./: startup_hc32m120.s
  group driver
    ../../../../driver/src/: hc32m120_gpio.c hc32m120_icg.c hc32m120_timerb.c hc32m120_usart.c hc32m120_utility.c hc32m120_clk.c hc32m120_interrupts.c
  group midware/lin
    ../../../../midware/lin/src/: lin.c
  group source
    ../source/: main.c
